; `circuit.Package` `gplugins.klayout.example`
; Generated by `vlsirtools.XyceNetlister`
;

.SUBCKT taper_L10_W100_W10_LNon_43bc52bd
+ 1
; No parameters

.ENDS

.SUBCKT pad_S100_100_LMTOP_BLNo_163fd346
+ 1 2
; No parameters

.ENDS

.SUBCKT pads_correct_Ppad_CSmetal3
; No ports
; No parameters

x1
+ tl,tr tl
+ pad_S100_100_LMTOP_BLNo_163fd346
+ ; No parameters

x2
+ tl,tr
+ taper_L10_W100_W10_LNon_43bc52bd
+ ; No parameters

x3
+ tl,tr tr
+ pad_S100_100_LMTOP_BLNo_163fd346
+ ; No parameters

x4
+ tl,tr
+ taper_L10_W100_W10_LNon_43bc52bd
+ ; No parameters

x5
+ bl,br br
+ pad_S100_100_LMTOP_BLNo_163fd346
+ ; No parameters

x6
+ bl,br bl
+ pad_S100_100_LMTOP_BLNo_163fd346
+ ; No parameters

x7
+ bl,br
+ taper_L10_W100_W10_LNon_43bc52bd
+ ; No parameters

x8
+ bl,br
+ taper_L10_W100_W10_LNon_43bc52bd
+ ; No parameters

.ENDS
